SRCDATE = "20190417"

require maxytec-recovery.inc

SRC_URI[md5sum] = "abc67410cc336b0cd88a78b544855dc3"
SRC_URI[sha256sum] = "58c299b83be3a15816e4f4edbce154f0621fd2e5046534664e37ef1f2c3b5910"

COMPATIBLE_MACHINE = "multibox"
