SRCDATE = "20200622"

require maxytec-libs.inc

SRC_URI[md5sum] = "99484caab1163d69ea9c04db1dd82dd0"
SRC_URI[sha256sum] = "58aad3348c457eb77d91538425889553004fd93a9be617d7d7cb60b9ab429db1"

COMPATIBLE_MACHINE = "multibox"
