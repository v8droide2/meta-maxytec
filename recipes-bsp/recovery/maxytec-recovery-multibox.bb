SRCDATE = "20201110"

require maxytec-recovery.inc

SRC_URI[md5sum] = "68ca177b0be5ffcc12fdab3989de8fd9"
SRC_URI[sha256sum] = "f1c726d24f5f1bf12024ef84fd3a00e2321884bbbc8de50a71de08107117d2f2"

COMPATIBLE_MACHINE = "multibox"
