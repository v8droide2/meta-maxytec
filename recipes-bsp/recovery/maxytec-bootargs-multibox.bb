SRCDATE = "20200424"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "cd851d3369bd281fcd02d3f3f0230be3"
SRC_URI[sha256sum] = "52144d4c10dd33f8f8d3d20475b99213e9f1f2590bcca1f34b425dea6b630062"

COMPATIBLE_MACHINE = "multibox"
