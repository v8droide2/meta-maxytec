SRCDATE = "20211209"

require maxytec-bootargs.inc

SRC_URI[md5sum] = "8aa3eb3f8322c5a8a9487613fd4f822c"
SRC_URI[sha256sum] = "da0e635d47864c131cbd9fbe4abf069f7b76872873bc6ce5fe409911245625ba"

COMPATIBLE_MACHINE = "multiboxpro"
