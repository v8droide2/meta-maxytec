SRCDATE = "20211208"

require maxytec-recovery.inc

SRC_URI[md5sum] = "33406c25805bd4454a95a46bd5ce65e7"
SRC_URI[sha256sum] = "59eaa4080c6bf260ee94a45135fe1d044f6545c10bd14151666778d4d5c62b3a"

COMPATIBLE_MACHINE = "multiboxpro"
