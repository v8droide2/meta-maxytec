SRCDATE = "20211209"

require maxytec-fastboot.inc

SRC_URI[md5sum] = "0b14fb6974aed5ead15f6f8811d6af72"
SRC_URI[sha256sum] = "8441d33e9acd02f78afb9f53cb04469d371b929003c8090e9bb0726910cb0e52"

COMPATIBLE_MACHINE = "multiboxpro"
